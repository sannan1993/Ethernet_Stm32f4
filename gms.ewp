# IAR project gms.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F405RG ST STM32F405RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F40_41xxx
  ICCARM.CCIncludePath2: E:\GMS_OLD VERSION\GMS_v0.01\inc; E:\GMS_OLD VERSION\GMS_v0.01\src; E:\GMS_OLD VERSION\GMS_v0.01; E:\GMS_OLD VERSION\GMS_v0.01\core; E:\GMS_OLD VERSION\GMS_v0.01\myHAL; myHAL; inc; src; $PROJ_DIR$; core; ethernet\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: gms.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c my_arduino.c my_arduino.h my_stdLib.c my_stdLib.h myStringLib.c myStringLib.h test_file.h
  group core
    core/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
    ./: startup_stm32f40xx.s
  group ethernet
    ethernet/src/: dhcp.c dnslkup.c enc28j60.c EtherShield.c ip_arp_udp_tcp.c websrv_help_functions.c
  group include
    inc/: ADE7758.h misc.h stm32f4xx.h stm32f4xx_adc.h stm32f4xx_conf.h stm32f4xx_gpio.h stm32f4xx_it.h stm32f4xx_iwdg.h stm32f4xx_rcc.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h system_stm32f4xx.h
    ./: attributes.h defines.h tm_stm32f4_adc.h tm_stm32f4_bkpsram.h tm_stm32f4_delay.h tm_stm32f4_gpio.h tm_stm32f4_spi.h
  group myHAL
    myHAL/: timer.c
  group source
    src/: misc.c stm32f4xx_adc.c stm32f4xx_gpio.c stm32f4xx_it.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c system_stm32f4xx.c
    ./: tm_stm32f4_adc.c tm_stm32f4_bkpsram.c tm_stm32f4_delay.c tm_stm32f4_gpio.c tm_stm32f4_spi.c tm_stm32f4_timer_properties.c
